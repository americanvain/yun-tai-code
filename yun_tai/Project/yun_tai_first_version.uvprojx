# Keil uVision project yun_tai_first_version.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: yun_tai_first_version
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER
  c include: ..\FWLIB\inc;..\CMSIS;..\USER\SYSTEM;..\HARDWARE;..\USER;..\APP;..\CONTROL;..\TRANSPORT
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: main.c
  group SYSTEM
    ../USER/SYSTEM/: delay.c sys.c
  group CORE
    ../CMSIS/: startup_stm32f427xx.s stm32f4xx_it.c system_stm32f4xx.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group HARDWARE
    ../HARDWARE/: remote_hardware.c power_ctrl.c led.c timer.c can.c buzzer.c
  group APP
    ../APP/: remote_app.c init.c can_task.c
  group TRANSPORT
    ../TRANSPORT/: can_data.c
  group CONTROL
    ../CONTROL/: friction_control.c motor_control.c pid.c ramp.c rammer_control.c gimbal_control.c chassis.c
